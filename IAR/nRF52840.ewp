# IAR project nRF52840.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52840_xxaa nRF52840_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NRF52840_XXAA; BOARD_PCA10056
  ICCARM.CCIncludePath2: ..; ..\src; ..\nRF52\system\toolchain; ..\nRF52\system\toolchain\cmsis\include; ..\nRF52\system\device; ..\nRF52\system\drivers; ..\nRF52\system\drivers\config; ..\nRF52\system\drivers\include; ..\nRF52\system\hal; ..\nRF52\system\util; ..\nRF52\core; ..\nRF52\core\avr; ..\nRF52\core\inc; ..\nRF52\core\drivers\inc; ..\nRF52\core\libraries\inc; ..\nRF52\boards; ..\nRF52\libraries\inc; ..\nRF52\system\libraries\atomic; ..\nRF52\system\libraries\atomic_fifo; ..\nRF52\system\libraries\balloc; ..\nRF52\system\libraries\block_dev; ..\nRF52\system\libraries\bsp; ..\nRF52\system\libraries\button; ..\nRF52\system\libraries\cli; ..\nRF52\system\libraries\cli\uart; ..\nRF52\system\libraries\crc16; ..\nRF52\system\libraries\crc32; ..\nRF52\system\libraries\csense; ..\nRF52\system\libraries\csense_drv; ..\nRF52\system\libraries\ecc; ..\nRF52\system\libraries\fds; ..\nRF52\system\libraries\experimental_log; ..\nRF52\system\libraries\experimental_log\src; ..\nRF52\system\libraries\experimental_memobj; ..\nRF52\system\libraries\experimental_ringbuf; ..\nRF52\system\libraries\experimental_section_vars; ..\nRF52\system\libraries\fifo; ..\nRF52\system\libraries\gpiote; ..\nRF52\system\libraries\hardfault; ..\nRF52\system\libraries\hardfault\nrf52; ..\nRF52\system\libraries\hci; ..\nRF52\system\libraries\led_softblink; ..\nRF52\system\libraries\low_power_pwm; ..\nRF52\system\libraries\mem_manager; ..\nRF52\system\libraries\mutex; ..\nRF52\system\libraries\pwm; ..\nRF52\system\libraries\pwr_mgmt; ..\nRF52\system\libraries\queue; ..\nRF52\system\libraries\sensorsim; ..\nRF52\system\libraries\scheduler; ..\nRF52\system\libraries\slip; ..\nRF52\system\libraries\strerror; ..\nRF52\system\libraries\timer; ..\nRF52\system\libraries\twi; ..\nRF52\system\libraries\twi_mngr; ..\nRF52\system\libraries\uart; ..\nRF52\system\libraries\usbd; ..\nRF52\system\libraries\usbd\class\audio; ..\nRF52\system\libraries\usbd\class\cdc; ..\nRF52\system\libraries\usbd\class\cdc\acm; ..\nRF52\system\libraries\usbd\class\hid; ..\nRF52\system\libraries\usbd\class\hid\generic; ..\nRF52\system\libraries\usbd\class\hid\kbd; ..\nRF52\system\libraries\usbd\class\hid\mouse; ..\nRF52\system\libraries\usbd\class\msc; ..\nRF52\system\libraries\usbd\config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: NRF52840_XXAA
  AARM.AUserIncludes: ..; ..\nRF52\system\toolchain; ..\nRF52\system\toolchain\cmsis\include; ..\nRF52\system\device
  OBJCOPY.OOCOutputFile: nRF52840.hex
  ILINK.IlinkOutputFile: nRF52840.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: 5.srec
  ILINK.IlinkOutputFile: cpp.out
  group (top)
    ../src/: main.cpp sdk_config.h
  group nRF52/boards
    ../nRF52/boards/: arduino_primo.h boards.c boards.h d52_starterkit.h n5_starterkit.h nrf6310.h pca10000.h pca10001.h pca10003.h pca10028.h pca10031.h pca10036.h pca10040.h pca10056.h pca20006.h wt51822.h
  group nRF52/core
    ../nRF52/core/: delay.c HardwareSerial.cpp itoa.c nRF52core.h Print.cpp Stream.cpp USBSerial.cpp wirish_digital.cpp wirish_math.cpp WString.cpp
  group nRF52/core/avr
    ../nRF52/core/avr/: dtostrf.c dtostrf.h pgmspace.h
  group nRF52/core/drivers
    ../nRF52/core/drivers/: nrf_drv_uarte.c
  group nRF52/core/drivers/inc
    ../nRF52/core/drivers/inc/: nrf_drv_uarte.h
  group nRF52/core/inc
    ../nRF52/core/inc/: delay.h HardwareSerial.h itoa.h pinName.h Print.h Printable.h Stream.h types.h USBSerial.h wirish_digital.h wirish_math.h WString.h
  group nRF52/core/libraries
    ../nRF52/core/libraries/: nRF52_FIFO.c nRF52_UART.c
  group nRF52/core/libraries/inc
    ../nRF52/core/libraries/inc/: nRF52_FIFO.h nRF52_UART.h
  group nRF52/system/device
    ../nRF52/system/device/: compiler_abstraction.h nrf.h nrf51.h nrf51422_peripherals.h nrf51802_peripherals.h nrf51822_peripherals.h nrf51_bitfields.h nrf51_deprecated.h nrf51_to_nrf52.h nrf51_to_nrf52810.h nrf51_to_nrf52840.h nrf52.h nrf52810.h nrf52810_bitfields.h nrf52810_peripherals.h nrf52832_peripherals.h nrf52840.h nrf52840_bitfields.h nrf52840_peripherals.h nrf52_bitfields.h nrf52_name_change.h nrf52_to_nrf52810.h nrf52_to_nrf52840.h
  group nRF52/system/drivers
    ../nRF52/system/drivers/: ble_flash.c nrf_drv_clock.c nrf_drv_common.c nrf_drv_comp.c nrf_drv_gpiote.c nrf_drv_i2s.c nrf_drv_lpcomp.c nrf_drv_pdm.c nrf_drv_power.c nrf_drv_ppi.c nrf_drv_pwm.c nrf_drv_qdec.c nrf_drv_qspi.c nrf_drv_rng.c nrf_drv_rtc.c nrf_drv_saadc.c nrf_drv_spi.c nrf_drv_spis.c nrf_drv_swi.c nrf_drv_systick.c nrf_drv_timer.c nrf_drv_twi.c nrf_drv_twis.c nrf_drv_uart.c nrf_drv_usbd.c nrf_drv_wdt.c nrf_nvic.c nrf_soc.c sdio.c
  group nRF52/system/drivers/config
    ../nRF52/system/drivers/config/: radio_config.c radio_config.h sdio_config.h twi_master_config.h
  group nRF52/system/drivers/include
    ../nRF52/system/drivers/inc/: ble_flash.h nrf_delay.h nrf_drv_clock.h nrf_drv_common.h nrf_drv_comp.h nrf_drv_gpiote.h nrf_drv_i2s.h nrf_drv_lpcomp.h nrf_drv_pdm.h nrf_drv_power.h nrf_drv_ppi.h nrf_drv_pwm.h nrf_drv_qdec.h nrf_drv_qspi.h nrf_drv_rng.h nrf_drv_rtc.h nrf_drv_saadc.h nrf_drv_spi.h nrf_drv_spis.h nrf_drv_swi.h nrf_drv_systick.h nrf_drv_timer.h nrf_drv_twi.h nrf_drv_twis.h nrf_drv_uart.h nrf_drv_usbd.h nrf_drv_usbd_errata.h nrf_drv_wdt.h nrf_error.h nrf_nvic.h nrf_soc.h sdio.h spi_5W_master.h twi_master.h
  group nRF52/system/hal
    ../nRF52/system/hal/: nrf_clock.h nrf_comp.h nrf_ecb.c nrf_ecb.h nrf_egu.h nrf_gpio.h nrf_gpiote.h nrf_i2s.h nrf_lpcomp.h nrf_nvmc.c nrf_nvmc.h nrf_pdm.h nrf_peripherals.h nrf_power.h nrf_ppi.h nrf_pwm.h nrf_qdec.h nrf_qspi.h nrf_rng.h nrf_rtc.h nrf_saadc.c nrf_saadc.h nrf_spi.h nrf_spim.h nrf_spis.h nrf_systick.h nrf_temp.h nrf_timer.h nrf_twi.h nrf_twim.h nrf_twis.h nrf_uart.h nrf_uarte.h nrf_usbd.h nrf_wdt.h
  group nRF52/system/toolchain
    ../nRF52/system/toolchain/iar/: iar_startup_nrf52840.s
    ../nRF52/system/toolchain/: system_nrf52840.c
  group nRF52/system/util
    ../nRF52/system/util/: app_error.c app_error.h app_error_weak.c app_error_weak.h app_util.h app_util_bds.h app_util_platform.c app_util_platform.h nordic_common.h nrf_assert.c nrf_assert.h nrf_bitmask.h sdk_common.h sdk_errors.h sdk_macros.h sdk_mapped_flags.c sdk_mapped_flags.h sdk_os.h sdk_resources.h
