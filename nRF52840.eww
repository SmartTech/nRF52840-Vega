<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IAR\nRF52840.ewp</path>
  </project>
  <batchBuild/>
</workspace>


